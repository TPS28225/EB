# Keil uVision project Pro.uvprojx, settings and files
target Pro (ARM-ADS)
  device: STM32F207ZGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,ARM_MATH_CM3
  c include: ..\App;..\BSP;..\Module;..\CMSIS\Core;..\CMSIS\Driver;..\UCOS\Source;..\UCOS\Port;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone;..\Utilities\Third_Party\lwip_v1.3.2\src\api;..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4;..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4\lwip;..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\Utilities\Third_Party\lwip_v1.3.2\src\netif\ppp;..\CMSIS\STM32F2xx_StdPeriph_Driver\inc;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\arch;..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7;..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\CMSIS\STM32F2x7_ETH_Driver\inc;..\CMSIS\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\CMSIS\CMSIS\CM3\CoreSupport;..\DRIVER;..\3rd;..\STemWin;..\STemWin\Config;..\STemWin\GUIDemo;..\STemWin\inc;..\STemWin\Lib;..\STemWin\Tutorial;..\FatFS;..\FatFS\src;..\FatFS\doc;..\FatFS\src\option;..\FATFS;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\FATFS\MMC_SD;..\FATFS\FLASH;..\FATFS\SPI;..\FATFS\TEXT;..\Malloc;..\EXAM;..\STemWin\font_chinese
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ../App/: Main.c Task_Test.c
  group BSP
    ../BSP/: Bsp_Global.c NVIC.C netconf.c stm32f2x7_eth_bsp.c stm32f2xx_it.c UDP_CLIENT.C TCP_CLIENT.C sram.c usart.c
  group CMSIS/Driver
    ../CMSIS/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group CMSIS/Core
    ../CMSIS/Core/: arm_math.h core_cmFunc.h core_cmInstr.h
    ../BSP/: system_stm32f2xx.c
    ../CMSIS/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group UCOS/Port
    ../UCOS/Port/: app_cfg.h os_cfg.h os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c ucosii_inc.h
  group UCOS/Source
    ../UCOS/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group LWIP
    ../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c mem.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c
    ../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group STM32F2x7_ETH_Driver
    ../CMSIS/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group I/O DEVICE
    ../DRIVER/: key.c LED.C config.c Beep.C MOTOR.C Zigbee.c BLUTOOTH.c delay.c UltrasonicWave.c dht11.c I2C.c LightIntensitySensor.c RC522.c spi_driver.c IR.c ILI93xx.c EV1527.c
  group FatFS
    ../FatFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c mycc936.c
    ../FATFS/MMC_SD/: mmc_sd.c
    ../FATFS/SPI/: spi.c
    ../FATFS/TEXT/: fontupd.c
    ../FATFS/FLASH/: flash.c
  group cJSON
    ../3rd/: cJSON.c parserJSON.c base64.c
  group STemwin_Config
    ../STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUIConf.h
    ../STemWin/OS/: GUI_X_uCOS.c
  group STemwin_LIB
    ../STemWin/Lib/: STemWin528_CM3_OS_Keil.lib
  group STemwin_Font
    ../STemWin/font_chinese/: xbffontcreate.c HZK_HWXK_24.c
  group EXAM
    ../EXAM/: Exam.c bmpdisplay.c
  group TXT
    ../App/: example.txt
